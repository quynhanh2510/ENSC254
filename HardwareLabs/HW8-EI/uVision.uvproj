# Keil uVision project uVision.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STR730FZ2 STMicroelectronics
  cpu: IRAM(0xA0000000-0xA0003FFF) IROM(0x80000000-0x8003FFFF) CLOCK(36000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ./
  asm misc: --diag_suppress=A1450E,A1608W --cpreproc
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
  group Startup Code
    ./: STR73x.s InitHw.c InitHw.h FIQ.inc
  group Interrupts
    ./: 73x_it.c 73x_it.h
  group System Calls
    ./: Retarget.c
  group Library
    ./: 73x_conf.h asm_include.h DAbt.s F_I_Bit.s FIQ.s IRQ.s PAbt.s SWI.s Undef.s 73x_cfg.c 73x_gpio.c 73x_uart.c 73x_prccu.c 73x_eic.c 73x_tim.c 73x_cmu.c 73x_tim_l.h 73x_eic_l.h cfg_eic.inc
  group Source Code
    ./: bigAdd.s main.c assembly.s BigFib.c
  group Documentation
    ./: Abstract.txt
target STR730 Board - Flash (ARM-ADS)
  device: STR730FZ2 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=4 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
