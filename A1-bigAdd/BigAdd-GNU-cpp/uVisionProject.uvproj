# Keil uVision project uVisionProject.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: uVisionProject
  group Source Group 1
    ./: Reset_Handler.S TestTableBigAdd.c bigAdd.cpp carried_primitive.hpp
