# Keil uVision project uVisionProject.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: uVisionProject
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  asm misc: --diag_suppress=A1450E
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Reset_Handler.S test.s bigAdd.S TestTableBigAdd.c simulator.ini
